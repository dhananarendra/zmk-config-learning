## boards/shields/learning/Kconfig.defconfig
```kconfig
if SHIELD_LEARNING

config ZMK_KEYBOARD_NAME
    default "learning"

endif # SHIELD_LEARNING
```
